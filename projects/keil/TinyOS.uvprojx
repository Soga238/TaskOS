# Keil uVision project TinyOS.uvprojx, settings and files
target TinyOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TinyOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group usr_app
    ../../usr_app/: main.c usr_app.c
  group kernel
    ../../kernel/source/: switch.c os_cpu.s tBitmap.c tList.c tTask.c tTime.c tCpu.c tEvent.c tSem.c tMbox.c tMemBlock.c tFlagGroup.c tMutex.c tTimer.c
    ../../kernel/source/include/: TinyOS.h tk_compiler.h tk_types.h tLib.h
  group bsp/rcc
    ../../bsp/rcc/: rcc.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
